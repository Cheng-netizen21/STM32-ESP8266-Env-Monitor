# Keil uVision project iap.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iap
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\Inc;D:\keil5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include;D:\keil5\ARM\Pack\Keil\STM32F1xx_DFP\2.2.0\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
    ./src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ./Inc/: misc.h stm32f10x_adc.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_conf.h
    D:/keil5/ARM/PACK/Keil/STM32F1xx_DFP/2.2.0/Device/Source/ARM/: startup_stm32f10x_md.s
